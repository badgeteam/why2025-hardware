File: power.kicad_sch (KiCad schematic)
At the start: 57 parts, among them J13 Battery, Q1 AP2302B, SW1 Power, U10 SY6280AAC, U11 AP3032KTR, U12 AP3032KTR, U15 DS8561-25S3, U6 BQ25895RTW, U7 TLV62595DMQR

Commit message: Small tweaks and fixes, update LCSC numbers on some components, change to new key type for power key
Parts:
- removed TP8: PA, TestPoint:TestPoint_Pad_D1.0mm, symbol Connector:TestPoint
- added R99: 4k7, Resistor_SMD:R_0402_1005Metric, symbol Device:R
- F2: value 1A -> 2A; LCSC C269107 -> C70158
- R20: LCSC (none) -> C7467416
- R48: LCSC (none) -> C25121
- R51: LCSC (none) -> C25077
- SW1: footprint Button_Switch_SMD:SW_SPST_PTS645 -> library:KEY-TH_TC-1101V-C-A-W
Connections:
- net PWR_ON: now also SW1.2, R99.1; no longer Q1.1 (G)
- net at Q1.3 (D), TP9.1, U6.12 (~{QON}): no longer SW1.2
- net PG: now reaches U7.2 (PG)
- new net: Q1.1 (G), R99.2
- no-connect marks 1 -> 0
Other:
- moved on the sheet: Q1, R31, SW1, TP9

Commit message: More routing, small fixes in schematic
Parts:
- removed C30, C58: 10u, Capacitor_SMD:C_1206_3216Metric, symbol Device:C
- removed R46: 100k, Resistor_SMD:R_0402_1005Metric, symbol Device:R
- removed R49: 4k7, Resistor_SMD:R_0402_1005Metric, symbol symbols:R
- removed U10: SY6280AAC, Package_TO_SOT_SMD:SOT-23-5, symbol symbols:AAT4610BIGV-1-T1-Power_Management
Other:
- note removed: "LED SWITCH"

Commit message: More routing, move PM I2C to ESP32-C6 instead of CH32
Parts:
- removed TH1: 10k, Resistor_SMD:R_0402_1005Metric, symbol Device:Thermistor_NTC
- removed TP10: TS, TestPoint:TestPoint_Pad_D1.0mm, symbol Connector:TestPoint
- added C46: 10u, Capacitor_SMD:C_1206_3216Metric, symbol Device:C
- R21: value 5k23 -> 10k
- R22: value 30k1 -> 10k
- SW1: symbol Switch:SW_Push -> pushbutton_gnd:pushbutton_gnd
Connections:
- net GND: now also SW1.2, SW1.3, SW1.4, C46.2; no longer SW1.1
- net PWR_ON: now also SW1.1; no longer SW1.2
- net VSYS: now also C46.1
Other:
- moved on the sheet: C12, R22

Commit message: All wires routed, lots of DRC errors to go
Parts:
- C13, C14, C15, C17, C18, C19, C31, C33, C46: footprint Capacitor_SMD:C_1206_3216Metric -> Capacitor_SMD:C_0805_2012Metric; LCSC C13585 -> C3039694
- R21, R22: LCSC (none) -> C60490
Changed lines of the file:
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@@
 			)
 		)
-		(property "Footprint" "Capacitor_SMD:C_1206_3216Metric"
+		(property "Footprint" "Capacitor_SMD:C_0805_2012Metric"
 			(at 162.2552 48.26 0)
 			(effects
@@
 			)
 		)
-		(property "Datasheet" "https://datasheet.lcsc.com/lcsc/2304140030_Samsung-Electro-Mechanics-CL31A106KBHNNNE_C13585.pdf"
+		(property "Datasheet" "https://www.lcsc.com/product-detail/Multilayer-Ceramic-Capacitors-MLCC-SMD-SMT_Samsung-Electro-Mechanics-CL21B106KAYQNNE_C3039694.html"
 			(at 161.29 44.45 0)
 			(effects
@@
 			)
 		)
-		(property "LCSC" "C13585"
+		(property "LCSC" "C3039694"
 			(at 161.29 44.45 0)
 			(effects
@@
 			)
 		)
-		(property "Footprint" "Capacitor_SMD:C_1206_3216Metric"
+		(property "Footprint" "Capacitor_SMD:C_0805_2012Metric"
 			(at 98.7552 44.45 0)
 			(effects
@@
 			)
 		)
-		(property "Datasheet" "https://datasheet.lcsc.com/lcsc/2304140030_Samsung-Electro-Mechanics-CL31A106KBHNNNE_C13585.pdf"
+		(property "Datasheet" "https://www.lcsc.com/product-detail/Multilayer-Ceramic-Capacitors-MLCC-SMD-SMT_Samsung-Electro-Mechanics-CL21B106KAYQNNE_C3039694.html"
 			(at 97.79 40.64 0)
 			(effects
@@
 			)
 		)
-		(property "LCSC" "C13585"
+		(property "LCSC" "C3039694"
 			(at 97.79 40.64 0)
 			(effects
@@
 			)
 		)
-		(property "Datasheet" ""
+		(property "Datasheet" "https://datasheet.lcsc.com/lcsc/2304140030_YAGEO-RC0402FR-0710KL_C60490.pdf"
 			(at 99.06 67.31 0)
 			(effects
@@
 			)
 		)
-		(property "LCSC" ""
+		(property "LCSC" "C60490"
 			(at 99.06 67.31 90)
 			(effects
@@
 			)
 		)
-		(property "Datasheet" ""
+		(property "Datasheet" "https://datasheet.lcsc.com/lcsc/2304140030_YAGEO-RC0402FR-0710KL_C60490.pdf"
 			(at 92.71 77.47 0)
 			(effects
@@
 			)
 		)
-		(property "LCSC" ""
+		(property "LCSC" "C60490"
 			(at 92.71 77.47 90)
 			(effects
@@
 			)
 		)
-		(property "Footprint" "Capacitor_SMD:C_1206_3216Metric"
+		(property "Footprint" "Capacitor_SMD:C_0805_2012Metric"
 			(at 220.6752 48.26 0)
 			(effects
@@
 			)
 		)
-		(property "Datasheet" "https://datasheet.lcsc.com/lcsc/2304140030_Samsung-Electro-Mechanics-CL31A106KBHNNNE_C13585.pdf"
+		(property "Datasheet" "https://www.lcsc.com/product-detail/Multilayer-Ceramic-Capacitors-MLCC-SMD-SMT_Samsung-Electro-Mechanics-CL21B106KAYQNNE_C3039694.html"
 			(at 219.71 44.45 0)
 			(effects
@@
 			)
 		)
-		(property "LCSC" "C13585"
+		(property "LCSC" "C3039694"
 			(at 219.71 44.45 0)
 			(effects
@@
 			)
 		)
-		(property "Footprint" "Capacitor_SMD:C_1206_3216Metric"
+		(property "Footprint" "Capacitor_SMD:C_0805_2012Metric"
 			(at 205.4352 48.26 0)
 			(effects
@@
 			)
 		)
-		(property "Datasheet" "https://datasheet.lcsc.com/lcsc/2304140030_Samsung-Electro-Mechanics-CL31A106KBHNNNE_C13585.pdf"
+		(property "Datasheet" "https://www.lcsc.com/product-detail/Multilayer-Ceramic-Capacitors-MLCC-SMD-SMT_Samsung-Electro-Mechanics-CL21B106KAYQNNE_C3039694.html"
 			(at 204.47 44.45 0)
 			(effects
@@
 			)
 		)
-		(property "LCSC" "C13585"
+		(property "LCSC" "C3039694"
 			(at 204.47 44.45 0)
 			(effects
@@
 			)
 		)
-		(property "Footprint" "Capacitor_SMD:C_1206_3216Metric"
+		(property "Footprint" "Capacitor_SMD:C_0805_2012Metric"
 			(at 213.0552 48.26 0)
 			(effects
@@
 			)
 		)
-		(property "Datasheet" "https://datasheet.lcsc.com/lcsc/2304140030_Samsung-Electro-Mechanics-CL31A106KBHNNNE_C13585.pdf"
+		(property "Datasheet" "https://www.lcsc.com/product-detail/Multilayer-Ceramic-Capacitors-MLCC-SMD-SMT_Samsung-Electro-Mechanics-CL21B106KAYQNNE_C3039694.html"
 			(at 212.09 44.45 0)
 			(effects
@@
 			)
 		)
-		(property "LCSC" "C13585"
+		(property "LCSC" "C3039694"
 			(at 212.09 44.45 0)
 			(effects
@@
 			)
 		)
-		(property "Footprint" "Capacitor_SMD:C_1206_3216Metric"
+		(property "Footprint" "Capacitor_SMD:C_0805_2012Metric"
 			(at 116.5352 59.69 0)
 			(effects
@@
 			)
 		)
-		(property "Datasheet" "https://datasheet.lcsc.com/lcsc/2304140030_Samsung-Electro-Mechanics-CL31A106KBHNNNE_C13585.pdf"
+		(property "Datasheet" "https://www.lcsc.com/product-detail/Multilayer-Ceramic-Capacitors-MLCC-SMD-SMT_Samsung-Electro-Mechanics-CL21B106KAYQNNE_C3039694.html"
 			(at 115.57 55.88 0)
 			(effects
@@
 			)
 		)
-		(property "LCSC" "C13585"
+		(property "LCSC" "C3039694"
 			(at 115.57 55.88 0)
 			(effects
@@
 			)
 		)
-		(property "Footprint" "Capacitor_SMD:C_1206_3216Metric"
+		(property "Footprint" "Capacitor_SMD:C_0805_2012Metric"
 			(at 105.1052 44.45 0)
 			(effects
@@
 			)
 		)
-		(property "Datasheet" "https://datasheet.lcsc.com/lcsc/2304140030_Samsung-Electro-Mechanics-CL31A106KBHNNNE_C13585.pdf"
+		(property "Datasheet" "https://www.lcsc.com/product-detail/Multilayer-Ceramic-Capacitors-MLCC-SMD-SMT_Samsung-Electro-Mechanics-CL21B106KAYQNNE_C3039694.html"
 			(at 104.14 40.64 0)
 			(effects
@@
 			)
 		)
-		(property "LCSC" "C13585"
+		(property "LCSC" "C3039694"
 			(at 104.14 40.64 0)
 			(effects
@@
 			)
 		)
-		(property "Footprint" "Capacitor_SMD:C_1206_3216Metric"
+		(property "Footprint" "Capacitor_SMD:C_0805_2012Metric"
 			(at 128.27 152.4 0)
 			(effects
@@
 			)
 		)
-		(property "Datasheet" "https://datasheet.lcsc.com/lcsc/2304140030_Samsung-Electro-Mechanics-CL31A106KBHNNNE_C13585.pdf"
+		(property "Datasheet" "https://www.lcsc.com/product-detail/Multilayer-Ceramic-Capacitors-MLCC-SMD-SMT_Samsung-Electro-Mechanics-CL21B106KAYQNNE_C3039694.html"
 			(at 128.27 152.4 0)
 			(effects
@@
 			)
 		)
-		(property "LCSC" "C13585"
+		(property "LCSC" "C3039694"
 			(at 128.27 152.4 0)
 			(effects
@@
 			)
 		)
-		(property "Footprint" "Capacitor_SMD:C_1206_3216Metric"
+		(property "Footprint" "Capacitor_SMD:C_0805_2012Metric"
 			(at 218.44 151.13 0)
 			(effects
@@
 			)
 		)
-		(property "Datasheet" "https://datasheet.lcsc.com/lcsc/2304140030_Samsung-Electro-Mechanics-CL31A106KBHNNNE_C13585.pdf"
+		(property "Datasheet" "https://www.lcsc.com/product-detail/Multilayer-Ceramic-Capacitors-MLCC-SMD-SMT_Samsung-Electro-Mechanics-CL21B106KAYQNNE_C3039694.html"
 			(at 218.44 151.13 0)
 			(effects
@@
 			)
 		)
-		(property "LCSC" "C13585"
+		(property "LCSC" "C3039694"
 			(at 218.44 151.13 0)
 			(effects

Commit message: Remove some items from BOM, generate fabrication files
Parts:
- TP1, TP11, TP12, TP13, TP14, TP2, TP9: now left out of the parts list
Changed lines of the file:
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@@
 		(unit 1)
 		(exclude_from_sim no)
-		(in_bom yes)
+		(in_bom no)
 		(on_board yes)
 		(dnp no)
@@
 		(unit 1)
 		(exclude_from_sim no)
-		(in_bom yes)
+		(in_bom no)
 		(on_board yes)
 		(dnp no)
@@
 		(unit 1)
 		(exclude_from_sim no)
-		(in_bom yes)
+		(in_bom no)
 		(on_board yes)
 		(dnp no)
@@
 		(unit 1)
 		(exclude_from_sim no)
-		(in_bom yes)
+		(in_bom no)
 		(on_board yes)
 		(dnp no)
@@
 		(unit 1)
 		(exclude_from_sim no)
-		(in_bom yes)
+		(in_bom no)
 		(on_board yes)
 		(dnp no)
@@
 		(unit 1)
 		(exclude_from_sim no)
-		(in_bom yes)
+		(in_bom no)
 		(on_board yes)
 		(dnp no)
@@
 		(unit 1)
 		(exclude_from_sim no)
-		(in_bom yes)
+		(in_bom no)
 		(on_board yes)
 		(dnp no)
