# Repository badgeteam/why2025-hardware

File README.md:

# WHY2025 badge

This repository contains the hardware design files for the [WHY2025](https://why2025.org) badge.

## Documentation

Detailed information can be found on our [website](https://badge.team/docs/badges/why2025/).

Need the schematic? [It's in this repository as a PDF file](schematic.pdf).

## License

This hardware design may be used under the terms of the [CERN-OHL-P](LICENSE) license.

All organization names, logos and trademarks such as but not limited to the Badge.Team name, logo and mascots, the WHY2025 name and logo and the Nicolai Electronics name and logo are all rights reserved for their respective owners and may not be reproduced on derrivative works.

An exception to this rule is the use of the Badge.Team name and logo when accompanied by clear text indicating that the derrived work is powered by or based on a design by Badge.Team.

## Authors

The electronics have been designed by [Renze Nicolai](https://github.com/renzenicolai) from [Nicolai Electronics](https://nicolaielectronics.nl) and [Paul Honig](https://github.com/ranzbak).

The WHY2025 badge frontpanel [artwork](frontpanel/neko) has been designed by [Nikolett, Ankhaneko.art](https://www.ankhaneko.art/).

The ergonomic board outline has been designed by [Jay Visschedijk](https://github.com/JayVisschedijk).

A special thanks to all the volunteers who contributed by helping with the routing and by debugging the hardware design:
 - [Kliment Yanev](https://github.com/kliment)
 - [Wietse Boonstra](https://github.com/Wietsman)
 - [Jelle Haandrikman](https://github.com/jhaand)

## KiCad design backexpansion/expansion-template/expansion-template.kicad_pcb

Parts:
H1, H2: Mounting hole; MountingHole_2.2mm_M2_DIN965_Pad
J1: Internal Add-On; HDR-TH_36P-P2.54-V-M-R2-C18-S2.54-1; LCSC C3975163
N1: Board-outline; why2025-mainboard-edge-cuts-usr
N2: Radio-logo; radio_logo

Connections:
+3.3V: J1.8, J1.33
E0: J1.11
E1: J1.12
E2: J1.13
E3: J1.14
E4: J1.15
E5: J1.16
E6: J1.17
E7: J1.20
E8: J1.27
E9: J1.25
E10: J1.23
E11: J1.21
E12: J1.19
EXT_INT: J1.18
EXT_USB_N: J1.24
EXT_USB_P: J1.22
GND: H1.1, H2.1, J1.6, J1.35
HUB_USB1_N: J1.4
HUB_USB1_P: J1.2
I2S_DATA: J1.31
I2S_LRCK: J1.30
I2S_MCLK: J1.29
I2S_SCLK: J1.32
I3C_SCL: J1.36
I3C_SDA: J1.34
INT_SCL: J1.9
INT_SDA: J1.10
P4_RX: J1.28
P4_TX: J1.26
VBATT: J1.3
VOTG: J1.1
VSDCARD: J1.7
VSYS: J1.5

Board: 4 copper layers, 44 parts (38 on the bottom side), 2 nets, no tracks yet.

Other parts of the board:
N2#2: Radio-logo; radio_logo
kibuzzard-672DEDFD: G***; kibuzzard-672DEDFD
kibuzzard-672DEE22: G***; kibuzzard-672DEE22
kibuzzard-672F44AA: G***; kibuzzard-672F44AA
kibuzzard-672F44B3: G***; kibuzzard-672F44B3
kibuzzard-672F44C7: G***; kibuzzard-672F44C7
kibuzzard-672F44D7: G***; kibuzzard-672F44D7
kibuzzard-672F44E2: G***; kibuzzard-672F44E2
kibuzzard-672F44E9: G***; kibuzzard-672F44E9
kibuzzard-672F44F4: G***; kibuzzard-672F44F4
kibuzzard-672F44FC: G***; kibuzzard-672F44FC
kibuzzard-672F45AF: G***; kibuzzard-672F45AF
kibuzzard-672F45BC: G***; kibuzzard-672F45BC
kibuzzard-672F45CE: G***; kibuzzard-672F45CE
kibuzzard-672F45D8: G***; kibuzzard-672F45D8
kibuzzard-672F45E8: G***; kibuzzard-672F45E8
kibuzzard-672F45EE: G***; kibuzzard-672F45EE
kibuzzard-672F45F5: G***; kibuzzard-672F45F5
kibuzzard-672F417C: G***; kibuzzard-672F417C
kibuzzard-672F452F: G***; kibuzzard-672F452F
kibuzzard-672F459A: G***; kibuzzard-672F459A
kibuzzard-672F460D: G***; kibuzzard-672F460D
kibuzzard-672F461C: G***; kibuzzard-672F461C
kibuzzard-672F463A: G***; kibuzzard-672F463A
kibuzzard-672F465A: G***; kibuzzard-672F465A
kibuzzard-672F466D: G***; kibuzzard-672F466D
kibuzzard-672F467D: G***; kibuzzard-672F467D
kibuzzard-672F4509: G***; kibuzzard-672F4509
kibuzzard-672F4510: G***; kibuzzard-672F4510
kibuzzard-672F4516: G***; kibuzzard-672F4516
kibuzzard-672F4522: G***; kibuzzard-672F4522
kibuzzard-672F4544: G***; kibuzzard-672F4544
kibuzzard-672F4557: G***; kibuzzard-672F4557
kibuzzard-672F4561: G***; kibuzzard-672F4561
kibuzzard-672F4600: G***; kibuzzard-672F4600
kibuzzard-672F4627: G***; kibuzzard-672F4627
kibuzzard-672F4631: G***; kibuzzard-672F4631
kibuzzard-672F4648: G***; kibuzzard-672F4648
kibuzzard-672F4776: G***; kibuzzard-672F4776

## KiCad design why2025.kicad_pcb

Board: 4 copper layers, 114.9 x 125.5 mm, 283 parts (108 on the bottom side), 248 nets.

Parts:
C1, C2, C3, C4, C5, C6, C10, C23, C26, C27, C28, C29, C35, C36, C37, C38, C40, C41, C42, C43, C44, C45, C46, C50, C51, C52, C53, C54, C55, C56, C57, C64, C73, C74, C75: 100n; C_0402_1005Metric
C7, C13, C14, C15, C17, C18, C19, C25, C30, C31, C33, C58: 10u; C_1206_3216Metric
C8, C9, C20, C32, C34, C39, C49, C61, C62, C63, C67: 1u; C_0603_1608Metric
C11: 47n; C_0603_1608Metric
C12: 4u7; C_0603_1608Metric
C16: 120p; C_0603_1608Metric
C21, C22, C24, C47, C48, C71, C72: 22p; C_0402_1005Metric
C65, C66: 22u; C_1206_3216Metric
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D22, D23, D24, D25, D26, D27, D28, D29, D30, D31, D32, D33, D34, D35, D36, D37, D38, D39, D40, D41, D42, D43, D44, D45, D46, D47, D48, D49, D50, D51, D52, D53, D54, D55, D56, D57, D58, D59, D60, D61, D62, D63, D64, D65, D66, D67, D68, D69, D70, D71, D72: LL4148; D_SOD-323
D73, D74, D75, D76, D77, D78, D80, D81: LED; LTW-010DCG-SR-G
D83, D84: 1N5819; D_SOD-323_HandSoldering
F1, F2: 1A; Fuse_0805_2012Metric
H1, H2, H3, H4, H5, H6: MountingHole_2.2mm_M2_Pad_Via
J1: USB device; USB_C_Receptacle_HRO_TYPE-C-31-M-12
J2: ESP32USB; USB-A-TH_JTJ-USB-A-F-10.0-010
J3: Internal I2C; 1X04_1MM_RA_GND
J5: External Add-On; PinSocket_2x08_P2.54mm_Horizontal
J6: Internal Add-On; PinSocket_2x18_P2.54mm_Vertical_SMD
J7: Speaker; Molex_PicoBlade_53261-0271_1x02-1MP_P1.25mm_Horizontal
J8: Micro_SD_Card; SD_Card-micro_socket_A
J10: Expansion I3C; 1X04_1MM_RA_GND
J14: LH397K; LH397K-IC01
JP1: BOOT; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
JP2, JP3, JP4, JP5: EN; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
L2: YHNR4020-2R2M; L_Wurth_WE-LQSH-4020
L3: FTC252010SR47MBCA; L_Wurth_WE-LQSH-2512
L4, L6: 6.8uH; L_1008_2520Metric
N1: Housing; proto1_kicad
Q4: AP2302B; SOT-23
R1, R2, R3, R4, R5, R6, R7, R8, R11, R13, R14, R15, R24, R28, R29, R38, R43, R50, R98: 10k; R_0402_1005Metric
R9, R10: 5k1; R_0402_1005Metric
R12, R25, R49, R53, R60, R61, R62, R63, R64, R65, R66: 4k7; R_0402_1005Metric
R16, R27, R31, R39, R46, R47, R70, R72: 100k; R_0402_1005Metric
R17, R18: 27; R_0402_1005Metric
R19: 2k2; R_0402_1005Metric
R20: 261; R_0402_1005Metric
R21: 5k23; R_0402_1005Metric
R22: 30k1; R_0402_1005Metric
R23: 45k3; R_0402_1005Metric
R26, R30, R33, R34, R35, R36, R37, R54, R55, R56, R57, R58, R59: 51k; R_0402_1005Metric
R32: 330; R_0402_1005Metric
R40, R41: 499k; R_0402_1005Metric
R44, R52: 4k02; R_0402_1005Metric
R48: 4R7; R_0603_1608Metric
R51: 10; R_0603_1608Metric
R67, R68: 33; R_0402_1005Metric
R69, R73: 0; R_0402_1005Metric
SW2: Button; SW_SPST_PTS645
TP1: BLKC; TestPoint_Pad_D1.0mm
TP2: BLLC; TestPoint_Pad_D1.0mm
TP3: PR1; TestPoint_Pad_D1.0mm
TP4: PR2; TestPoint_Pad_D1.0mm
TP5: PR3; TestPoint_Pad_D1.0mm
TP6: PR4; TestPoint_Pad_D1.0mm
TP7: PRR; TestPoint_Pad_D1.0mm
TP8: PA; TestPoint_Pad_D1.0mm
TP9: ~{QON}; TestPoint_Pad_D1.0mm
TP10: TS; TestPoint_Pad_D1.0mm
TP11: BLL+; TestPoint_Pad_D1.0mm
TP12: BLL-; TestPoint_Pad_D1.0mm
TP13: BLK+; TestPoint_Pad_D1.0mm
TP14: BLK-; TestPoint_Pad_D1.0mm
U1: LQFP-48_7x7mm_P0.5mm
U2: keyboard_arturo182
U3: TLV62569DBV; SOT-23-5
U4: CH334R; QSOP-16_3.9x4.9mm_P0.635mm
U5: ESP32-C6-WROOM-1
U6: BQ25895RTW; Texas_S-PWQFN-N24_EP2.7x2.7mm_ThermalVias
U8: ESP32P4-REV0; esp32p4rev0
U11, U12: AP3032KTR; SOT-23-6
U13: W25Q128JVS; SOIC-8_5.23x5.23mm_P1.27mm
U14: VQFN-20-1EP_3x3mm_P0.4mm_EP1.7x1.7mm
U15: DS8561-25S3; SOT-23
U16: FM8002A; SSOP-8_3.9x5.05mm_P1.27mm
U20: 74LVC1G125; SOT-353_SC-70-5
U21: LM339; SOIC-14_3.9x8.7mm_P1.27mm
Y1: 12MHz; Crystal_SMD_3225-4Pin_3.2x2.5mm
Y2: 32.768KHz; Crystal_SMD_3215-2Pin_3.2x1.5mm

Connections:
+2.5vsb: C2.1, C58.1, U1.1 (VBAT), U15.2 (VO)
+3.3V: C1.1, C3.1, C4.1, C5.1, C10.1, C16.1, C17.1, C18.1, C19.1, C37.1, C43.1, C44.1, C45.1, C51.1, C54.1, C55.1, C56.1, C57.1, C63.1, C64.1, J5.15, J6.6, J6.29, J14.23 (VCI), J14.24 (IOVCC), JP1.2 (B), L3.2, R12.1, R13.2, R15.1, R16.1, R23.2, R25.1, R28.1, R29.1, R30.1, R33.1, R34.1, R35.1, R36.1, R37.1, R38.2, R43.2, R50.2, R53.2, R60.2, R61.2, R62.2, R63.2, R64.2, R65.2, R66.2, R73.1, R98.2, U1.9 (VDDA), U1.24 (VDDIO1), U1.36 (VDD2), U1.48 (VDDIO3), U3.4 (VIN), U5.2 (3V3), U8.10 (VDDPST_1), U8.22 (VDDPST_2), U8.52 (VCCA), U8.63 (VDDPST_4), U8.76 (VDDPST_LDO), U8.78 (VDDPST_DCDC), U8.97 (VDDPST_6), U8.102 (VDDA), U8.103 (VBAT), U14.4 (DVDD), U14.5 (PVDD), U21.3 (V+)
+3.3VA: C67.1, R70.2, R72.2, R73.2, U14.16 (AVDD)
+3V3: J3.2 (VCC), J10.2 (VCC)
+BL-KB: C32.1, D76.2 (A), D77.2 (A), D83.1 (K), TP13.1, U11.5 (OV)
+BL-LCD: C34.1, D84.1 (K), J14.2 (LEDA), TP11.1, U12.5 (OV)
-BL-KB: D73.1 (K), D81.1 (K), R48.1, TP14.1, U11.3 (FB)
-BL-LCD: J14.1 (LEDK), R51.1, TP12.1, U12.3 (FB)
/Application processor/C6_CLK: R33.2, U5.17 (GPIO19), U8.23 (GPIO20)
/Application processor/C6_CMD: R30.2, U5.16 (GPIO18), U8.24 (GPIO21)
/Application processor/C6_D0: R34.2, U5.18 (GPIO20), U8.18 (GPIO16)
/Application processor/C6_D1: R35.2, U5.19 (GPIO21), U8.19 (GPIO17)
/Application processor/C6_D2: R36.2, U5.20 (GPIO22), U8.20 (GPIO18)
/Application processor/C6_D3: R37.2, U5.21 (GPIO23), U8.21 (GPIO19)
/Application processor/CH32_SWCLK: U1.37 (PA14), U8.26 (GPIO23)
/Application processor/CH32_SWDIO: U1.34 (PA13), U8.25 (GPIO22)
/Application processor/DSI_CLK_N: J14.7 (TCP), U8.38 (DSI_CLKN)
/Application processor/DSI_CLK_P: J14.8 (TCN), U8.39 (DSI_CLKP)
/Application processor/DSI_D0_N: J14.5 (TDN0), U8.41 (DSI_DATAN0)
/Application processor/DSI_D0_P: J14.4 (TDP0), U8.40 (DSI_DATAP0)
/Application processor/DSI_D1_N: J14.11 (TDN1), U8.37 (DSI_DATAN1)
/Application processor/DSI_D1_P: J14.10 (TDP1), U8.36 (DSI_DATAP1)
/Application processor/I2S_DATA: U8.58 (GPIO28), U14.8 (SDIN)
/Application processor/I2S_LRCK: U8.62 (GPIO31), U14.9 (LRCK)
/Application processor/I2S_MCLK: U8.61 (GPIO30), U14.3 (MCLK)
/Application processor/I2S_SCLK: U8.59 (GPIO29), U14.7 (SCLK)
/Application processor/LCD_TE: J14.20 (TE), R98.1, U8.1 (GPIO0)
/Application processor/Protection/~RESET: C46.1, JP2.1 (A), JP3.1 (A), JP4.1 (A), JP5.1 (A), R43.1, U8.104 (CHIP_PU)
/Application processor/SD_CLK: J8.5 (CLK), R55.1, U8.85 (GPIO43)
/Application processor/SD_CMD: J8.3 (CMD), R54.1, U8.87 (GPIO44)
/Application processor/SD_D0: J8.7 (DAT0), R59.1, U8.81 (GPIO39)
/Application processor/SD_D1: J8.8 (DAT1), R58.1, U8.82 (GPIO40)
/Application processor/SD_D2: J8.1 (DAT2), R57.1, U8.83 (GPIO41)
/Application processor/SD_D3: J8.2 (DAT3/CD), R56.1, U8.84 (GPIO42)
/Application processor/UART_RX: U5.25 (U0TXD/GPIO16), U8.70 (GPIO37)
/Application processor/UART_TX: U5.24 (U0RXD/GPIO17), U8.71 (GPIO38)
/Application processor/USB1_P1_N: U4.3 (DM3-), U8.54 (GPIO25)
/Application processor/USB1_P1_P: U4.4 (DP3+), U8.53 (GPIO24)
/Application processor/USB_DM: J2.2 (D-), U8.50 (DM)
/Application processor/USB_DP: J2.3 (D+), U8.51 (DP)
/Audio/SPK+: J7.1, U16.8 (VO2)
/Audio/SPK-: J7.2, U16.5 (VO1)
/CC1: J1.A5 (CC1), R9.2
/CC2: J1.B5 (CC2), R10.2
/Coprocessor/ALARM: R31.2, TP8.1, U1.2 (PC13)
/Coprocessor/C6_BOOT: R38.1, U1.45 (PB8), U5.15 (GPIO9)
/Coprocessor/C6_EN: R13.1, U1.46 (PB9), U5.3 (EN/CHIP_PU)
/Coprocessor/DISPLAY_BL: R27.2, TP2.1, U1.40 (PB4), U12.4 (CTRL)
/Coprocessor/KEYBOARD_BL: R47.2, TP1.1, U1.39 (PB3), U11.4 (CTRL)
/Coprocessor/Keyboard/EXT_I: D48.2 (A), SW2.1
/Coprocessor/LCD_RST: J14.21 (RESET), R50.1, U1.6 (PD1)
/Coprocessor/PM_INT: R15.2, U1.38 (PA15), U6.7 (INT)
/Coprocessor/PM_SCL: R25.2, U1.21 (PB10), U6.5 (SCL)
/Coprocessor/PM_SDA: R12.2, U1.22 (PB11), U6.6 (SDA)
/Coprocessor/USB_1_N: U1.32 (PA11), U4.7 (DM1-)
/Coprocessor/USB_1_P: U1.33 (PA12), U4.8 (DP1+)
/LEDs/DIN: R26.1, U5.11 (GPIO10), U20.2
/Power/VLED_EN: R46.2, U5.5 (MTDI/GPIO5/ADC1_CH5)
/Power/~DSEL: R11.2, U4.9 (~RESET/CDP), U6.24 (DSEL)
/Radio/D+: R17.1, U4.6 (DP2+)
/Radio/D-: R18.1, U4.5 (DM2-)
/USB_DEVICE_N: J1.A7 (D-), J1.B7 (D-), U4.10 (DMU-), U6.3 (D-)
/USB_DEVICE_P: J1.A6 (D+), J1.B6 (D+), U4.11 (DPU+), U6.2 (D+)
/USB_VBUS: F1.2, J1.A4 (VBUS), J1.A9 (VBUS), J1.B4 (VBUS), J1.B9 (VBUS)
E0: J6.15, U8.66 (GPIO34)
E1: J6.16, U8.67 (GPIO35)
E2: J6.17, U8.69 (GPIO36)
E3: J6.18, U8.88 (GPIO45)
E4: J6.19, U8.89 (GPIO46)
E5: J6.20, U8.90 (GPIO47)
E6: J6.21, U8.91 (GPIO48)
E7: J6.22, R28.2, R53.1, R60.1, U1.10 (PA0), U8.93 (GPIO49)
E8: J6.23, R16.2, R61.1, U5.10 (GPIO8), U8.94 (GPIO50)
E11: J3.4 (SCL), J6.9, J6.26, R64.1, U1.42 (PB6), U5.7 (MTDO/GPIO7), U8.98 (GPIO53), U14.2 (CCLK)
E12: J6.27, U8.99 (GPIO54)
EXT_INT: J6.24, J6.28, R62.1, U8.95 (GPIO51)
EXT_USB_N: J6.14, U8.57 (GPIO27)
EXT_USB_P: J6.13, U8.56 (GPIO26)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C12.2, C13.2, C14.2, C15.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C25.2, C26.2, C27.2, C28.2, C29.2, C30.2, C31.2, C32.2, C33.2, C34.2, C35.2, C36.2, C37.2, C38.2, C39.2, C40.2, C41.2, C42.2, C43.2, C44.2, C45.2, C46.2, C47.2, C48.2, C49.2, C50.2, C51.2, C52.2, C53.2, C54.2, C55.2, C56.2, C57.2, C58.2, C73.2, C74.2, C75.2, H1.1, H2.1, H3.1, H4.1, H5.1, H6.1, J1.A1 (GND), J1.A12 (GND), J1.B1 (GND), J1.B12 (GND), J1.S1 (SHIELD), J2.4 (GND), J2.5 (Shield), J3.1 (GND), J3.5, J3.6, J5.5, J5.10, J5.16, J6.4, J6.30, J8.6 (VSS)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
GNDA: C61.2, C62.2, C63.2, C64.2, C67.2, C71.2, C72.2, J7.MP (MountPin), Q4.2 (S), R69.2, U14.6 (DGND), U14.13 (AGND), U14.19 (CE), U14.21 (PGND), U16.7 (GND)
HP_DET: R70.1, U1.41 (PB5)
HUB_USB_N: J6.32, U4.1 (DM4-)
HUB_USB_P: J6.31, U4.2 (DP4+)
I3C_SCL: J6.11, J10.4 (SCL), U8.65 (GPIO33)
I3C_SDA: J6.12, J10.3 (SDA), U8.64 (GPIO32)
INT_SDA: J3.3 (SDA), J6.10, J6.25, R63.1, U1.43 (PB7), U5.6 (MTCK/GPIO6/ADC1_CH6), U8.96 (GPIO52), U14.1 (CDATA)
KB_COL0: D1.1 (K), D3.1 (K), D5.1 (K), D25.1 (K), D27.1 (K), D44.1 (K), D49.1 (K), D51.1 (K), D53.1 (K), R1.1, U1.27 (PB14)
KB_COL1: D7.1 (K), D9.1 (K), D11.1 (K), D29.1 (K), D31.1 (K), D45.1 (K), D55.1 (K), D57.1 (K), D59.1 (K), R2.1, U1.25 (PB12)
KB_COL2: D13.1 (K), D15.1 (K), D17.1 (K), D34.1 (K), D36.1 (K), D46.1 (K), D61.1 (K), D63.1 (K), D65.1 (K), R3.1, U1.19 (PB1)
KB_COL3: D19.1 (K), D21.1 (K), D23.1 (K), D39.1 (K), D41.1 (K), D47.1 (K), D67.1 (K), D69.1 (K), D71.1 (K), R4.1, U1.17 (PA7)
KB_COL4: D2.1 (K), D4.1 (K), D6.1 (K), D26.1 (K), D28.1 (K), D33.1 (K), D50.1 (K), D52.1 (K), D54.1 (K), R5.1, U1.28 (PB15)
KB_COL5: D8.1 (K), D10.1 (K), D12.1 (K), D30.1 (K), D32.1 (K), D38.1 (K), D56.1 (K), D58.1 (K), D60.1 (K), R6.1, U1.26 (PB13)
KB_COL6: D14.1 (K), D16.1 (K), D18.1 (K), D35.1 (K), D37.1 (K), D43.1 (K), D62.1 (K), D64.1 (K), D66.1 (K), R7.1, U1.20 (PB2)
KB_COL7: D20.1 (K), D22.1 (K), D24.1 (K), D40.1 (K), D42.1 (K), D48.1 (K), D68.1 (K), D70.1 (K), D72.1 (K), R8.1, U1.18 (PB0)
KB_ROW0: U1.29 (PA8), U2.1 (ESC), U2.3 (F1), U2.5 (F2), U2.7 (F3), U2.17 (`), U2.19 (1), U2.21 (2), U2.23 (3)
KB_ROW1: U1.30 (PA9), U2.43 (TAB), U2.45 (Q), U2.47 (W), U2.49 (E), U2.69 (FN), U2.71 (A), U2.73 (S), U2.75 (D)
KB_ROW2: U1.31 (PA10), U2.95 (SHL), U2.97 (Z), U2.99 (X), U2.101 (C), U2.121 (CTRL), U2.123 (MT), U2.125 (ALT), U2.127 (\)
KB_ROW3: U1.14 (PA4), U2.25 (4), U2.27 (5), U2.29 (6), U2.31 (7), U2.51 (R), U2.53 (T), U2.55 (Y), U2.57 (U)
KB_ROW4: U1.13 (PA3), U2.77 (F), U2.79 (G), U2.81 (H), U2.83 (J), U2.103 (V), U2.105 (B), U2.107 (N), U2.109 (M)
KB_ROW5: U1.11 (PA1), U2.9 (F4), U2.11 (F5), U2.13 (F6), U2.15 (BS), U2.35 (9), U2.37 (0), U2.39 (-), U2.41 (=)
KB_ROW6: U1.16 (PA6), U2.61 (O), U2.63, U2.65 ([), U2.67 (]), U2.87 (L), U2.89 (;), U2.91 ('), U2.93 (RET)
KB_ROW7: U1.15 (PA5), U2.113 (.), U2.115 (/), U2.117 (/\), U2.119 (SHR), U2.135 (AGR), U2.137 (<), U2.139 (\/), U2.141 (>)
KB_ROW8: SW2.2, U1.12 (PA2), U2.33 (8), U2.59 (I), U2.85 (K), U2.111 (,), U2.129 (SP), U2.131 (SP), U2.133 (SP)
MTCK: J5.6, U8.3 (GPIO2)
MTDI: J5.2, U8.4 (GPIO3)
MTDO: J5.4, U8.6 (GPIO5)
MTMS: J5.8, U8.5 (GPIO4)
unnamed: C11.1, L2.1, U6.19 (SW), U6.20 (SW)
unnamed: C65.2, R67.1
unnamed: C66.2, R68.1
unnamed: D1.2 (A), U2.2
unnamed: D2.2 (A), U2.18
unnamed: D3.2 (A), U2.44
unnamed: D4.2 (A), U2.70
unnamed: D5.2 (A), U2.96
unnamed: D6.2 (A), U2.122
unnamed: D7.2 (A), U2.4
unnamed: D8.2 (A), U2.20
unnamed: D9.2 (A), U2.46
unnamed: D10.2 (A), U2.72
unnamed: D11.2 (A), U2.98
unnamed: D12.2 (A), U2.124
unnamed: D13.2 (A), U2.6
unnamed: D14.2 (A), U2.22
unnamed: D15.2 (A), U2.48
unnamed: D16.2 (A), U2.74
unnamed: D17.2 (A), U2.100
unnamed: D18.2 (A), U2.126
unnamed: D19.2 (A), U2.8
unnamed: D20.2 (A), U2.24
unnamed: D21.2 (A), U2.50
unnamed: D22.2 (A), U2.76
unnamed: D23.2 (A), U2.102
unnamed: D24.2 (A), U2.128
unnamed: D25.2 (A), U2.26
unnamed: D26.2 (A), U2.52
unnamed: D27.2 (A), U2.78
unnamed: D28.2 (A), U2.104
unnamed: D29.2 (A), U2.28
unnamed: D30.2 (A), U2.54
unnamed: D31.2 (A), U2.80
unnamed: D32.2 (A), U2.106
unnamed: D33.2 (A), U2.130
unnamed: D34.2 (A), U2.30
unnamed: D35.2 (A), U2.56
unnamed: D36.2 (A), U2.82
unnamed: D37.2 (A), U2.108
unnamed: D38.2 (A), U2.132
unnamed: D39.2 (A), U2.32
unnamed: D40.2 (A), U2.58
unnamed: D41.2 (A), U2.84
unnamed: D42.2 (A), U2.110
unnamed: D43.2 (A), U2.134
unnamed: D44.2 (A), U2.34
unnamed: D45.2 (A), U2.60
unnamed: D46.2 (A), U2.86
unnamed: D47.2 (A), U2.112
unnamed: D49.2 (A), U2.10
unnamed: D50.2 (A), U2.36
unnamed: D51.2 (A), U2.62
unnamed: D52.2 (A), U2.88
unnamed: D53.2 (A), U2.114
unnamed: D54.2 (A), U2.136
unnamed: D55.2 (A), U2.12
unnamed: D56.2 (A), U2.38
unnamed: D57.2 (A), U2.64
unnamed: D58.2 (A), U2.90
unnamed: D59.2 (A), U2.116
unnamed: D60.2 (A), U2.138
unnamed: D61.2 (A), U2.14
unnamed: D62.2 (A), U2.40
unnamed: D63.2 (A), U2.66
unnamed: D64.2 (A), U2.92
unnamed: D65.2 (A), U2.118
unnamed: D66.2 (A), U2.140
unnamed: D67.2 (A), U2.16
unnamed: D68.2 (A), U2.42
unnamed: D69.2 (A), U2.68
unnamed: D70.2 (A), U2.94
unnamed: D71.2 (A), U2.120
unnamed: D72.2 (A), U2.142
unnamed: D73.2 (A), D74.1 (K)
unnamed: D74.2 (A), D75.1 (K)
unnamed: D75.2 (A), D76.1 (K)
unnamed: D77.1 (K), D78.2 (A)
unnamed: D78.1 (K), D80.2 (A)
unnamed: D80.1 (K), D81.2 (A)
unnamed: D83.2 (A), L6.2, U11.1 (SW)
unnamed: D84.2 (A), L4.2, U12.1 (SW)
unnamed: JP1.1 (A), R14.1, U1.44 (BOOT0)
unnamed: JP2.2 (B), TP3.1, U21.2
unnamed: JP3.2 (B), TP4.1, U21.1
unnamed: JP4.2 (B), TP5.1, U21.13
unnamed: JP5.2 (B), TP6.1, U21.14
unnamed: TP9.1, U6.12 (~QON)
unnamed: Q4.3 (D), U16.1 (SHUTDOWN)
unnamed: C23.1, R29.2, U1.7 (NRST)
unnamed: C22.1, U1.3 (PC14), Y2.2
unnamed: C21.1, U1.4 (PC15), Y2.1
unnamed: R39.2, U3.1 (EN), U8.80 (EN_DCDC)
unnamed: C24.2, R40.1, R41.2, U3.5 (FB), U8.79 (FB_DCDC)
unnamed: C6.1, C7.1, U4.13 (VDD33)
unnamed: U4.16 (XI), Y1.1
unnamed: U4.15 (XO), Y1.3
unnamed: R18.2, U5.13 (GPIO12/USB_D-)
unnamed: R17.2, U5.14 (GPIO13/USB_D+)
unnamed: R32.1, U5.4 (MTMS/GPIO4/ADC1_CH4)
unnamed: C11.2, U6.21 (BTST)
unnamed: R20.1, U6.10 (ILIM)
unnamed: C12.1, R21.2, U6.22 (REGN)
unnamed: R19.1, U6.4 (STAT)
unnamed: R21.1, R22.2, TP10.1, U6.11 (TS)
unnamed: C16.2, R23.1, R24.2
unnamed: R44.1, U8.49 (CSI_REXT)
unnamed: R52.1, U8.35 (DSI_REXT)
unnamed: C48.1, U8.100 (XTAL_N)
unnamed: C47.1, U8.101 (XTAL_P)
unnamed: U8.33 (FLASH_CK), U13.6 (CLK)
unnamed: U8.34 (FLASH_D), U13.5 (DI(IO0))
unnamed: U8.29 (FLASH_Q), U13.2 (DO(IO1))
unnamed: U8.30 (FLASH_WP), U13.3 (IO2)
unnamed: U8.32 (FLASH_HOLD), U13.7 (IO3)
unnamed: U8.28 (FLASH_CS), U13.1 (~CS)
unnamed: C71.1, U14.14 (LOUTN)
unnamed: C65.1, C72.1, U14.15 (LOUTP)
unnamed: C66.1, U14.11 (ROUTP)
unnamed: C61.1, U14.18 (VMID)
unnamed: C62.1, U14.17 (VRP)
unnamed: C74.1, U21.5 (+)
unnamed: C73.1, TP7.1, U21.4 (-), U21.6 (-), U21.8 (-), U21.10 (-)
unnamed: C28.1, U21.7 (+)
unnamed: C29.1, U21.11 (+)
unnamed: C75.1, U21.9 (+)
SAO_IO1: J5.11, U8.16 (GPIO14)
SAO_IO2: J5.12, U8.17 (GPIO15)
SAO_IO3: J5.7, U8.2 (GPIO1)
SAO_SCL: J5.14, R66.1, U8.15 (GPIO13)
SAO_SDA: J5.13, R65.1, U8.14 (GPIO12)
VBATT: C15.1, F2.2, J6.2, U6.13 (BAT), U6.14 (BAT), U15.3 (VI)
VBUS: C9.1, F1.1, J6.1, U6.1 (VBUS)
VESPHP: C24.1, C25.1, C26.1, C27.1, C35.1, C36.1, R40.2, U8.27 (VDD_HP_0), U8.55 (VDD_HP_1), U8.77 (VDD_HP_2), U8.92 (VDD_HP_3)
VFLASH: C42.1, C49.1, C50.1, U8.31 (VDDPST_3), U8.72 (VFB/VO1), U13.8 (VCC)
VLED: C30.1, J5.3, U20.5 (VCC)
VMIPI: C41.1, C52.1, U8.42 (VDD_MIPI_DPHY), U8.74 (VFB/VO3)
VOTG: C20.1, J2.1 (VBUS), J6.3, R11.1, U6.23 (PMID)
VPSRAM: C38.1, C39.1, U8.60 (VDDPST), U8.68 (VDDPST), U8.73 (VFB/VO2)
VSDCARD: C40.1, C53.1, J6.7, J8.4 (VDD), R54.2, R55.2, R56.2, R57.2, R58.2, R59.2, U8.75 (VFB/VO4), U8.86 (VDDPST_5)
VSYS: C8.1, C13.1, C14.1, C31.1, C33.1, J5.9, J6.5, L2.2, L4.1, L6.1, U4.12 (V5), U6.8 (OTG), U6.15 (SYS), U6.16 (SYS), U11.6 (VIN), U12.6 (VIN), U16.6 (VDD)

## Commit log

2024-03-13 Keyboard matrix
2024-03-13 Add library folder, add symbols, add footprint for keyboard by Jay
2024-03-15 Keyboard stuff, experiments
2024-03-16 Add radio, wire up more stuff
2024-03-17 Relabeling of ESP32-C6 GPIO, route signals to expansion header for testing
2024-03-18 Boot pin, bit more routing
2024-03-19 Added ESP32-p4 symbol + footprint
2024-03-21 added footprints for: PJ-327C-4A, SHOU HAN TF-CARD H1.8, USB-A: 908-371A1011D10100
2024-03-25 A bit of progress
2024-04-01 Work in progress
2024-04-01 More work on power schematic
2024-04-07 Stuff.
2024-04-16 P4 stuff
2024-04-17 Mostly power related stuff for the ESP32-P4
2024-04-23 More schematics
2024-04-28 More fixes, add display, update display backlight driver circuit, fix some of the footprint associations
2024-05-05 More work on the schematic, add protection circuit, fix display pinout
2024-05-06 Assign footprints, create P4 footprint
2024-05-06 added PJ-327ST-SMT footprint
2024-05-07 Bill of materials part 1
2024-05-07 Bill of materials part 2
2024-05-09 Updated voltage regulator safety
2024-05-09 Extra text added to protection circuit page.
2024-05-10 Updated dates on circuit diagrams.
2024-05-12 Small tweaks and fixes, update LCSC numbers on some components, change to new key type for power key
2024-05-13 Change side expansion header, add 3d models, move connectors and change board outline
2024-05-14 Route LED driver, sort PMIC components.
2024-05-14 Some more component placement
2024-05-16 More routing, small fixes in schematic
2024-05-17 More routing and fixes
2024-05-17 Routed the USB and MIPI lines with the correct impedance.
2024-05-17 Some extra routing and fixes. +3.3V and +3v3 labels both used
2024-05-18 Extra routing. Changed diff pair clearenc, and track width.
2024-05-19 Routed more stuff.
2024-05-19 More routing, move PM I2C to ESP32-C6 instead of CH32
2024-05-19 More routing, moved some more signals
2024-05-20 All wires routed, lots of DRC errors to go
2024-05-20 Remove a lot of DRC errors, free up VCC layer a bit more.
2024-05-20 Remove old files
2024-05-20 Fix 0nm secions in board outline DRC error
2024-05-20 Fix some more DRC errors
2024-05-21 Removed all the errors, warnings remaining, J2 needs to be fixed in library.
2024-05-21 Fix last errors, add speaker footprint
2024-05-22 Add more testpoints for CH32, add text, move addressable LEDs further apart
2024-05-22 Add stamp, add spacer to silkscreen
2024-05-22 Remove some items from BOM, generate fabrication files
2024-05-22 More fabrication stuff for prototype 1
2024-05-24 Production version of prototype 1
2024-05-25 Frontpanel stuff
2024-05-26 Frontpanel :D
2024-05-26 Add 3d printable spacer files
2024-06-21 Disconnect PMIC from USB device port data lines, power USB hub by VBUS
2024-07-15 Add 1uF capacitor to fix DC current through speaker.
2024-07-22 18-Add correct display connector
2024-07-22 Didn't I save all?
2024-07-27 Rerouting to get LORA chip fitted.
2024-07-27 Fixes
2024-07-27 Move LoRa capacitor
2024-07-28 Replaced voltage comparitor circuit with zener setup. Also changed couple of 0.2mm vias to 0.3
2024-07-28 Move protection diode for VFLASH, solve DRC errors, clean up
2024-07-29 Add the missing LCSC number to the Zener, add comment VESPHP is not related with a Zener.
2024-07-29 add pullup for lora CS, SMA marked as dnp
2024-07-29 Disconnect PG from reset of P4, connect to GPIO of CH32, fix warnings, make some vias bigger, add BHI360
2024-07-29 Add protection for overvoltage vcore, via Opamp that pulls enable low on regulator when vcore > 1.2V
2024-07-30 Moved antenna more away from wifi, replaced more 0.2 with 0.3 mm vias.
2024-07-31 push push
2024-07-31 Resized all 0.2 mm hole vias to 0.3, cleaned up routing. 1 error 13 warnings remaining.
2024-08-01 Fix audio amplifier circuit
2024-08-02 Proposal to add 6 mounting holes where users can screw battery boards or what ever to the badge, provide footprint + outline too if good idea?
2024-08-03 Remove vcore protection
2024-08-03 Fix DRC errors
2024-08-03 Clean up routing on the board, freeing up the second layer.
2024-08-04 Add 5 10uF capacitors at the USB A port.
2024-08-04 Add components to be able to use the bhi360 IC
2024-08-04 PCB update.
2024-08-05 Standoffs, move connectors, bigger trace for vbatt
2024-08-06 Better copper between IC and L
2024-08-06 Add Open hardware logo, and copper pour for the 1.8V rail.
2024-08-08 Add LEDs for artwork
2024-08-08 Add version of proto1 frontpanel design without whypad
2024-08-08 add frontpanel template
2024-08-10 Work in progress moving around the PMIC to be closer to the battery connector.
2024-08-11 Almost done.
2024-08-11 little vsys improvement, extra via in rail.
2024-08-11 Add frontpanel svg without whypad, add frontpanel template svg
2024-08-11 New P4 footprint, LED stuff, move PMIC I2C to CH32
2024-08-11 New footprint for P4
2024-08-11 Shifted diff pairs, moved wires left of p4 to make more space for vias.
2024-08-11 Fix pinout of P4 again :-(
2024-08-12 fix-esp-p4-pin-55-54
2024-08-12 Route more stuff, swapped IO/pins to fit routing better.
2024-08-12 Route all unrouted wires, connect I2S to expansion header
2024-08-13 Add 1v8 LDO regulator to provide for the 1.8V, migth need to be set to do not populate.
2024-08-13 Add 1v8 regulator, reroute some tracks to make space for regulater.
2024-08-13 Fixed all errors but the 2 keep out zone violations.
2024-08-13 Clean up board, no errors left.
2024-08-17 All traces removed from layer 2. Added missing 3d package for VSON-14
2024-08-17 Add datasheet for df3znb connector.
2024-08-21 LED placement
2024-08-23 Add Bosch sensor, fix small things, add speaker hole etc...
2024-08-23 Add readme, update date on schematic, export schematic
2024-08-23 Update production files
2024-08-23 Saving the project before committing helps
2024-08-24 Small fixes
2024-08-24 More SAO
2024-08-24 More fixes, replace the external expansion header with through hole connector
2024-08-25 Add ESD protection to USB ports, remove fuse from USB-C port, small fixes
2024-08-26 More ESD protection, design stuff
2024-08-26 Change some of the routing based on feedback by Kliment
2024-09-01 Rerouted the I2C bus to the audio chip, didn't like the long loop created by the previous routing.
2024-09-03 Add PCB probe/jumper is i2c bus to PMIC, add Ranzbak logo.
2024-09-03 Optimize routing a bit, cleaning up weird corners in traces.
2024-09-04 U7 VCC to 0.4mm trace width.
2024-09-04 Add GND vias next to GND pads that were missing them.
2024-09-05 Fixed some routing, add wireless radiation warning logo.
2024-09-06 Optimized routing around C6
2024-09-08 Move inductor closer to bq25895 to be absolutely sure we are working as efficient as possible.
2024-09-08 Fix spacing error.
2024-09-08 Make TE a bit bigger, add 3d model of P4, align logos
2024-09-09 Battery trace to PMIC 1mm wide now.
2024-09-09 VBATT trace in now 1,2mm.
2024-09-10 VBATT trace now to 1.5mm
2024-09-11 Connect C6 RX/TX, change exp header pinout
2024-09-11 Add ESD protection LCSC number
2024-09-11 Add Bosch logo, first attempt at creating thermal separation for BME690
2024-09-11 Add LCSC number for ESP32-P4
2024-09-12 Add accelerometer interrupt
2024-09-13 Last fixes, different coils for backlight dc/dc
2024-09-14 Clean up and split frontpanel files
2024-09-14 Add keepout zones for copper on template frontpanel
2024-09-15 Update schematic PDF
2024-09-16 Add frontpanel design by Nikolett, add template with SAO connector hole
2024-09-16 Add cyberdeck frontpanel design
2024-09-17 Update frontpanel design by Nikolett
2024-09-17 Add step files
2024-10-04 VBUS trace wider to PMIC, moved signal out under USB diff pair line, fix RX/TX P4.
2024-10-04 Add extra capacitance to VSYS to decouple the backlight driver more from VSYS.
2024-10-05 Add schottky diode D87 to make high Aperage OTG conversion more efficient.
2024-10-06 Add 1.5k pull-up to D+ of C6, remove logos, add JTAG connector, fix SAO pinout
2024-10-07 add missing signals to J11, P4 reset and E2
2024-10-10 85: Changed SMA footprint for LORA to use: Samtec_SMA-J-P-H-ST-EM1_EdgeMount
2024-10-12 Change ch32v203 datasheet to english version.
2024-10-13 Made more space around the D87, smooth curve LORA antenna.
2024-10-18 Add extra header for JTAG reset and detect.
2024-10-18 Add replace bme680 with bme688 on the design.
2024-10-20 Fix Ground detect for JTAG pin.
2024-10-20 Swapped GPIO32 and GPIO00, added functionality to use 1 3v3 pin as the P4 RESET.
2024-10-28 Change internal I2C bus 4.7k pullups to 2.2k, in order to get a better rise time on the signal.
2024-10-29 Add latch to power on from the ch32.
2024-10-30 Shortened VBATT, rerouted VBUS to a less crowded part of the PCB and it's now 1.2mm. Moved vias tohove ground in between for better EM.
2024-10-30 Fixed little issues found by KiCad inspection tool.
2024-11-01 Switch SDA and SCL I3C bus as they were switched.
2024-11-01 Fix SR latch circuit
2024-11-01 Add resistor to USB-serial TX pin, solve DRC warnings
2024-11-01 Update footprints from library to solve DRC warnings
2024-11-01 Move charging status LED
2024-11-01 WIP: change LED, camera, LoRa and C6 pins and add USB-A port 1A current limit
2024-11-01 Add missing routing.
2024-11-01 Add BMI270 sensor
2024-11-01 Add another speaker hole :)
2024-11-04 Inner layer copper <-> plain clearance set to 0.2mm for with VCC and GND. Add vias to make ground plains more continues.
2024-11-04 Move BME688 to left grill, add I2C testpoints
2024-11-04 Change value of R86 to 2.2k, fix some LCSC numbers
2024-11-09 Add basic template for badge back expansion.
2024-11-09 Use board setup from badge design to give sane defaults when desiging the expansion board.
2024-11-10 Make the board 2mm taller to reach 70mm hight, this allows production at JLCPCB without the need for panneling.
2024-11-10 Add pads for connecting to frontpanel
2024-11-10 Add LED to top right corner
2024-11-11 Move micro sd card slot, remove E1 from the expansion header
2024-11-14 Change TE resistor to 100k pull-down and export production files
2024-11-15 Change some resistors from 10k to 51k, fused 5k1 2x to 10k resistor.
2024-11-16 Some unsaved changes.
2024-11-16 Fix 180k resistor that JLCPB didn't have in stock.
2024-11-16 Production files as used to manufacture prototype 3
2024-11-28 fixed SCL SDA swap on PCA9517 chip.
2024-12-16 Remove non-why2025 frontpanel designs
