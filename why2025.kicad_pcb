File: why2025.kicad_pcb (KiCad board)
At the start: 4 copper layers, 114.9 x 125.5 mm, 234 parts, among them J1 USB device, J2 ESP32USB, J4 Headphones, J5 External Add-On, J6 Internal Add-On, J7 Speaker, J8 Micro_SD_Card, U11 AP3032KTR, U12 AP3032KTR, U13 W25Q128JVS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

Commit message: More fixes, add display, update display backlight driver circuit, fix some of the footprint associations
Parts:
- removed D79: LED, badgeteam:LTW-010DCG-SR-G
- added C58: 10uF, Capacitor_SMD:C_1206_3216Metric, F.Cu at (179.3, -88.8)
- added SW2: Button, Button_Switch_SMD:SW_SPST_PTS645, B.Cu at (0.00, 23.0)
- added U15: DS8561-25S3, Package_TO_SOT_SMD:SOT-23, F.Cu at (130.7, -108.5)
- added Y4: 32.768KHz, Crystal:Crystal_SMD_3215-2Pin_3.2x1.5mm, F.Cu at (130.8, -114.6)
- L7: value 6.8uH -> 22uH; footprint Inductor_SMD:L_1008_2520Metric -> Inductor_SMD:L_Changjiang_FNR252010S
- R26: value 4.7k -> 51k
- R27: value 4.7k -> 100k
- R47: value 4.7K -> 100k; footprint Resistor_SMD:R_0603_1608Metric -> Resistor_SMD:R_0402_1005Metric
- R50: value 4.7K -> 10k; footprint Resistor_SMD:R_0603_1608Metric -> Resistor_SMD:R_0402_1005Metric
- R51: value 10 -> 14R7
- U12: value AP3032KTR -> AP3127B
- moved R26 73.4 mm to (187.9, -83.9)
- moved R27 67.1 mm to (183.0, -86.1)
- moved R47 35.8 mm to (183.0, -84.1)
- moved R50 25.7 mm to (136.6, -110.0)
Connections:
- net /Coprocessor/B3 renamed /Coprocessor/KEYBOARD_BL
- net /Coprocessor/D0 renamed /Coprocessor/VLED_EN
- net E9 renamed EXT_INT
- C2 pad 1: +3.3vsb -> +2.5vsb
- C44 pad 1: +3.3vsb -> +3.3V
- C8 pad 1: VOTG -> VSYS
- D48 pad 2: /Coprocessor/Keyboard/EXT -> /Coprocessor/Keyboard/EXT_I
- D73 pad 1: Net-(D73-K) -> -BL-KB
- D76 pad 2: Net-(D76-A) -> +BL-KB
- D77 pad 2: Net-(D76-A) -> +BL-KB
- D80 pad 2: Net-(D79-K) -> Net-(D78-K)
- D81 pad 1: Net-(D73-K) -> -BL-KB
- R26 pad 1: +3.3V -> /LEDs/DATA
- R26 pad 2: INT_SDA -> GND
- R27 pad 1: +3.3V -> GND
- R27 pad 2: INT_SCL -> /Coprocessor/DISPLAY_BL
- R50 pad 1: GND -> /Coprocessor/LCD_RST
- R50 pad 2: /Coprocessor/B4 -> +3.3V
- TP2 pad 1: /Coprocessor/B4 -> /Coprocessor/DISPLAY_BL
- U1 pad 1: +3.3vsb -> +2.5vsb
- U1 pad 40: /Coprocessor/B4 -> /Coprocessor/DISPLAY_BL
- U1 pad 6: /Coprocessor/D1 -> /Coprocessor/LCD_RST
- U12 pad 4: /Coprocessor/B4 -> /Coprocessor/DISPLAY_BL
- U4 pad 12: VOTG -> VSYS
- U5 pad 11: LED_DATA -> /LEDs/DATA
Routing:
- net Net-(D73-K): track 148.5 -> 0.00 mm, vias 2 -> 0
- net -BL-KB: track 0.00 -> 148.5 mm, vias 0 -> 2
- net Net-(D76-A): track 140.1 -> 0.00 mm
- net +BL-KB: track 0.00 -> 140.1 mm
- net /Coprocessor/Keyboard/EXT_I: track 0.00 -> 102.7 mm, vias 0 -> 2
- net INT_SDA: track 47.3 -> 0.00 mm, vias 2 -> 0
- net E12: track 0.00 -> 47.3 mm, vias 0 -> 2
- net INT_SCL: track 40.1 -> 0.00 mm, vias 2 -> 0
- net EXT_INT: track 0.00 -> 40.1 mm, vias 0 -> 2
- net Net-(D79-K): track 10.8 -> 0.00 mm
- net Net-(D78-K): track 10.8 -> 21.7 mm
- net KB_ROW8: track 54.5 -> 64.1 mm, vias 1 -> 2
